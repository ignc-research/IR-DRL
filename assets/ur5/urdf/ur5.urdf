Commit message: training now runs correctly

File: assets/ur5/urdf/ur5.urdf (robot description, URDF)
Before this commit: robot ur5_with_torch, 9 links, 8 joints
Links:
- link ee_link: geometry collision cylinder length=0.03 radius=0.006; visual cylinder length=0.04 radius=0.006
